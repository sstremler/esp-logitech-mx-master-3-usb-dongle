## sdkconfig.defaults
```kconfig
#
# BT config
#
CONFIG_BT_ENABLED=y
CONFIG_BT_BLUEDROID_ENABLED=n
CONFIG_BT_NIMBLE_ENABLED=y

CONFIG_TINYUSB_HID_COUNT=1
CONFIG_BT_NIMBLE_NVS_PERSIST=y
```
